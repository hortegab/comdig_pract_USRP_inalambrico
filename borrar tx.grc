<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Lab_total</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B</value></param>
<param><key>value</key><value>2*BW</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BW</value></param>
<param><key>value</key><value>W*(1.+rolloff)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B_usrp</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps</value></param>
<param><key>value</key><value>int(math.log(M,2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>value</key><value>[(1+0j), (0+1j), (-1+0j), (0 -1j)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>(digital.constellation_bpsk(), digital.constellation_qpsk(), digital.constellation_8psk(), digital.qam.qam_constellation(16))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[(1+1.j)/4.24,(3+1.j)/4.24,(3+3.j)/4.24,(1+3.j)/4.24,(-1+1.j)/4.24,(-3+1.j)/4.24,(-3+3.j)/4.24,(-1+3.j)/4.24,(-1-1.j)/4.24,(-3-1.j)/4.24,(-3-3.j)/4.24,(-1-3.j)/4.24,(1-1.j)/4.24,(3-1.j)/4.24,(3-3.j)/4.24,(1-3.j)/4.24]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>900e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Gain_USRP_Rx_dB</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>controls@0:0,2,1,1</value></param>
<param><key>label</key><value>Gain_USRP_Rx (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>130</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Gain_USRP_Tx_dB</value></param>
<param><key>value</key><value>30.</value></param>
<param><key>gui_hint</key><value>controls@0:0,1,1,1</value></param>
<param><key>label</key><value>Gain_USRP_Tx (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>130</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kd</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(Constelacion)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>MiconstellationObject</value></param>
<param><key>const_points</key><value>Constelacion</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value></value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbpCode</value></param>
<param><key>value</key><value>len(code1)+10.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>Rs*Bps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rbi</value></param>
<param><key>value</key><value>Rb/(1+NbpCode/payload)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>samp_rate/Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps_o</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Tmax_scope</value></param>
<param><key>value</key><value>64./Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>W</value></param>
<param><key>value</key><value>Rs/2.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code1</value></param>
<param><key>value</key><value>'010110011011101100010101011111101001001110001011010001101010001'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>Sps*16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0.9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps_rx</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(Sps), rolloff, ntaps*nfilts)</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(samp_rate_usrp_rx/Kd)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_usrp_rx</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Instrumentos</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label0</key><value>Capa0.Canal y precanal</value></param>
<param><key>label1</key><value>Capas.Pre-modulacion</value></param>
<param><key>label2</key><value>Capa1. Modulacion</value></param>
<param><key>label3</key><value>Capa2. CodificacionDeSimbolos</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Pre_modulacion</value></param>
<param><key>gui_hint</key><value>Instrumentos@1:1,0,1,1</value></param>
<param><key>label0</key><value>Capa8.Mensaje continuo</value></param>
<param><key>label1</key><value>Capa7.Cuantificacion</value></param>
<param><key>label2</key><value>Capa6.PCM</value></param>
<param><key>label3</key><value>Capa5.Otrastecnicas</value></param>
<param><key>label4</key><value>Capa4.CodificacionBinaria</value></param>
<param><key>label5</key><value>Capa3.M-PAM</value></param>
<param><key>num_tabs</key><value>6</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/uis-e3t/LIBRERIAS/comdig_pract_USRP_inalambrico/texto1.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>canal</value></param>
<param><key>gui_hint</key><value>Instrumentos@0:1,0,1,1</value></param>
<param><key>label0</key><value>Constelacion</value></param>
<param><key>label1</key><value>Espectro</value></param>
<param><key>label2</key><value>Medidores</value></param>
<param><key>label3</key><value>histograma</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>controls</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label0</key><value>Tuning</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_scipy</value></param>
<param><key>import</key><value>from scipy import fftpack</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>Rb</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
